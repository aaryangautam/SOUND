options:
  parameters:
    author: Solomon
    copyright: Solomon
    generate_options: no_gui
    id: learning_fhss
    output_language: python
    title: Frequency Hopping Spread Spectrum Lab
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '144850000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: '144000000'
    step: '1'
    stop: '145000000'
    value: '144850000'
  states: {state: disabled}
- name: noise_lvl
  id: variable_qtgui_range
  parameters:
    label: Noise Lvl
    start: '0'
    step: '0.01'
    stop: '0.1'
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 4.8e6
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_args: center_freq
    function_name: change_channel
    poll_rate: '5'
    value: '0'
  states: {}
- name: vol_lvl
  id: variable_qtgui_range
  parameters:
    label: Volume Lvl
    start: '0'
    step: '0.5'
    stop: '5'
    value: '1'
  states: {state: disabled}
- name: vol_lvl
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*(5e3)/samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_lvl
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_lvl
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/Documents/TE/SDRtransmittest.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_out(pmt.intern("freq"))
              self.channel = 0

          def work(self, input_items, output_items):
              """Useless function"""
              return len(output_items[0])

          def change_channel(self, center_freq):
              self.channel = (self.channel + 3)%8
              freq = center_freq + (self.channel * -100e3)
              P_freq_cmd = pmt.cons(pmt.string_to_symbol("freq"), pmt.from_double(freq))
              self.message_port_pub(pmt.intern("freq"), P_freq_cmd)
              return 1
    comment: The FHSS Freq Synthesizer for hopping
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 3e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '30'
    bw0: '2000000'
    freq0: center_freq
    gain0: '20'
    if_gain0: '30'
    sample_rate: '32000'
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Channel"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: TX and Channel
    label1: RX
    label2: Audio
    num_tabs: '3'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_antenna
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_noise_source_x_0, '0', blocks_throttle_0_1, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0_1, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, freq, freq_xlating_fir_filter_xxx_1, freq]
- [filter_fft_low_pass_filter_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
